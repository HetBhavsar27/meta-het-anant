FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SPLASH_IMAGES:rpi = "file://redbull_f1_png.png;outsuffix=raspberrypi"
